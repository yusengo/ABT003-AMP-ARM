# IAR project vcan_Kinetis.ewp, settings and files
configuration FX15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60X512.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FX15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB; ..\..\App\modbus; ..\..\App\modbus\mb_port; ..\..\App\modbus\mb_core\ascii; ..\..\App\modbus\mb_core\functions; ..\..\App\modbus\mb_core\include; ..\..\App\modbus\mb_core\rtu; ..\..\App\modbus\mb_core\tcp
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\App\modbus\mb_core\include; ..\..\App\modbus\mb_core\functions; ..\..\App\modbus\mb_core\rtu; ..\..\App\modbus\mb_port; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
  group App
    ../../App/: ABT_Key.c AD7705.c gemcreate_probe_cmd.c main.c MainBoard.c MBK60Set.c MK60_conf.c MK60_it.c
    ../../App/Inc/: AD7705.h MainBoard.h MK60_conf.h MK60_it.h PORT_cfg.h
  group Board
    ../../Board/src/: VCAN_key.c VCAN_LED.C
  group Chip
    ../../Chip/inc/: common.h MK60_dac.h
    ../../Chip/src/: misc.c MK60_adc.c MK60_dac.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group ModBus
    ../../App/modbus/: modbus_op.c modbus_op.h
  group ModBus/core
    ../../App/modbus/mb_core/: mb.c
  group ModBus/core/ascii
    ../../App/modbus/mb_core/ascii/: mbascii.c mbascii.h
  group ModBus/core/functions
    ../../App/modbus/mb_core/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group ModBus/core/include
    ../../App/modbus/mb_core/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group ModBus/core/rtu
    ../../App/modbus/mb_core/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group ModBus/core/tcp
    ../../App/modbus/mb_core/tcp/: mbtcp.c mbtcp.h
  group ModBus/port
    ../../App/modbus/mb_port/: port.h portevent.c portother.c portserial.c porttimer.c vendor_func.c vendor_func.h
